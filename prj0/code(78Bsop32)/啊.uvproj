# Keil uVision project 啊.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5276B tenx
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM(0xFE00-0xFFFF)
  output: 啊
  c flags: Optimize=8 SizeSpeed=1
